options:
  parameters:
    generate_options: qt_gui
    id: demod
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: deci_factor
  id: variable
  parameters:
    value: '32'
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: '2000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    const_points: '[-1, 1]'
    precision: '8'
    rot_sym: '1'
    sym_map: '[-1, 1]'
    type: bpsk
  states: {}
- name: variable_low_pass_filter_taps_0
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '2800'
    gain: '1.0'
    samp_rate: samp_rate
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(deci_factor*2*math.pi*fsk_deviation_hz)
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-30'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/arno/Schreibtisch/out.txt
    type: byte
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/arno/Schreibtisch/gqrx_20230416_153033_432199000.wav
    nchan: '2'
    repeat: 'False'
  states: {state: disabled}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: variable_constellation_0
    damping: '1.0'
    loop_bw: '0.04'
    max_dev: '1.3'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '4'
    ted_gain: '1.0'
    ted_type: digital.TED_MENGALI_AND_DANDREA_GMSK
    type: ff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: deci_factor
    samp_rate: samp_rate
    taps: variable_low_pass_filter_taps_0
    type: ccc
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    ant0: LNAW
    bb_gain0: '0'
    freq0: 432.2e6
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"SYNC"'
    nconnections: '2'
    size: '500'
    srate: samp_rate/deci_factor
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    update_time: '0.05'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: '8'
    samp_rate: samp_rate/deci_factor
    sym_rate: '3000'
    type: fir_filter_fff
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', root_raised_cosine_filter_0, '0']
- [analog_simple_squelch_cc_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0_0, '1']
- [digital_binary_slicer_fb_0, '0', digital_map_bb_0, '0']
- [digital_map_bb_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_map_bb_0, '0', blocks_uchar_to_float_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [osmosdr_source_0, '0', analog_simple_squelch_cc_0, '0']
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
