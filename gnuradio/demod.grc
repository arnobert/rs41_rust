options:
  parameters:
    generate_options: qt_gui
    id: demod
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: '2500'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: smps_sym
  id: variable_qtgui_range
  parameters:
    label: SAMPLES PER SYMBOL
    start: '2'
    step: '1'
    stop: '1000'
    value: '300'
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: variable_low_pass_filter_taps_0
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '3000'
    gain: '1.0'
    samp_rate: samp_rate
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*fsk_deviation_hz)
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-30'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/arno/Schreibtisch/out.txt
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/arno/Schreibtisch/gqrx_20230416_153033_432199000.wav
    nchan: '2'
    repeat: 'False'
  states: {state: disabled}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: variable_constellation_0
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: smps_sym
    ted_gain: '1.0'
    ted_type: digital.TED_ZERO_CROSSING
    type: ff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: variable_low_pass_filter_taps_0
    type: ccc
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    comment: netcat -ul 127.0.0.1 2000 | hexdump
    header: '0'
    payloadsize: '1472'
    port: '2000'
    send_eof: 'False'
    type: float
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    ant0: LNAW
    bb_gain0: '0'
    freq0: 432.2e6
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '16000'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', digital_symbol_sync_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0, '0']
- [analog_simple_squelch_cc_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_symbol_sync_xx_0, '0', network_udp_sink_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', analog_simple_squelch_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
